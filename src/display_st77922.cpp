// ST77922 QSPI driver.
// Init table is Freenove's own st77922_lcd_init[] (from their TFT_eSPI fork),
// as transcribed in github.com/emailman/Freenove_FNK0104N_MicroPython.
// QSPI framing: 8-bit opcode + 24-bit address (register << 8).
//   opcode 0x02 = register write, data on 1 line
//   opcode 0x32 = pixel write,    data on 4 lines
#include "display_st77922.h"
#include "config.h"
#include <driver/spi_master.h>
#include <esp_heap_caps.h>
#include <string.h>

namespace St77922 {

static spi_device_handle_t s_dev = nullptr;
static uint8_t* s_band = nullptr;          // DMA-capable bounce buffer
static const int BAND_ROWS = 20;           // rows per transfer
static const int BAND_BYTES = LCD_NATIVE_W * BAND_ROWS * 2;

static void writeReg(uint8_t reg, const uint8_t* data, size_t len) {
  spi_transaction_t t = {};
  t.cmd = 0x02;
  t.addr = (uint32_t)reg << 8;
  if (len) {
    t.length = len * 8;
    if (len <= 4) {
      t.flags = SPI_TRANS_USE_TXDATA;
      memcpy(t.tx_data, data, len);
    } else {
      t.tx_buffer = data;
    }
  }
  spi_device_polling_transmit(s_dev, &t);
}

static inline void writeReg(uint8_t reg, std::initializer_list<uint8_t> d) {
  uint8_t buf[16];
  size_t n = 0;
  for (uint8_t b : d) buf[n++] = b;
  writeReg(reg, buf, n);
}

static void writePixels(uint8_t reg, const uint8_t* data, size_t len) {
  spi_transaction_t t = {};
  t.cmd = 0x32;
  t.addr = (uint32_t)reg << 8;
  t.flags = SPI_TRANS_MODE_QIO;   // data phase on 4 lines, cmd/addr on 1 line
  t.length = len * 8;
  t.tx_buffer = data;
  spi_device_polling_transmit(s_dev, &t);
}

static void initPanel() {
  writeReg(0xF1, {0x00});
  writeReg(0x60, {0x00, 0x00, 0x00});
  writeReg(0x65, {0x80});
  writeReg(0x79, {0x06});
  writeReg(0x7B, {0x00, 0x08, 0x08});
  writeReg(0x80, {0x55, 0x62, 0x2F, 0x17, 0xF0, 0x52, 0x70, 0xD2, 0x52, 0x62, 0xEA});
  writeReg(0x81, {0x26, 0x52, 0x72, 0x27});
  writeReg(0x84, {0x92, 0x25});
  writeReg(0x87, {0x10, 0x10, 0x58, 0x00, 0x02, 0x3A});
  writeReg(0x88, {0x00, 0x00, 0x2C, 0x10, 0x04, 0x00, 0x00, 0x00, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x06});
  writeReg(0x89, {0x00, 0x00, 0x00});
  writeReg(0x8A, {0x13, 0x00, 0x2C, 0x00, 0x00, 0x2C, 0x10, 0x10, 0x00, 0x3E, 0x19});
  writeReg(0x8B, {0x15, 0xB1, 0xB1, 0x44, 0x96, 0x2C, 0x10, 0x97, 0x8E});
  writeReg(0x8C, {0x1D, 0xB1, 0xB1, 0x44, 0x96, 0x2C, 0x10, 0x50, 0x0F, 0x01, 0xC5, 0x12, 0x09});
  writeReg(0x8D, {0x0C});
  writeReg(0x8E, {0x33, 0x01, 0x0C, 0x13, 0x01, 0x01});
  writeReg(0xB3, {0x00, 0x30});
  writeReg(0xF1, {0x00});
  writeReg(0x71, {0xD0});
  writeReg(0x66, {0x02, 0x3F});
  writeReg(0xBE, {0x26, 0x00, 0x9D});
  writeReg(0x70, {0x01, 0xA0, 0x11, 0x40, 0xE0, 0x00, 0x11, 0x69, 0x11, 0x00, 0x00, 0x1A});
  writeReg(0x90, {0x04, 0x04, 0x55, 0x74, 0x00, 0x40, 0x43, 0x27, 0x27});
  writeReg(0x91, {0x04, 0x04, 0x55, 0x75, 0x00, 0x40, 0x42, 0x27, 0x27});
  writeReg(0x92, {0x04, 0x44, 0x55, 0xC0, 0x06, 0x00, 0x07, 0x05, 0x90, 0x27});
  writeReg(0x93, {0x04, 0x43, 0x11, 0x00, 0x00, 0x00, 0x00, 0x05, 0x90, 0x27});
  writeReg(0x94, {0x00, 0x00, 0x00, 0x00, 0x00, 0x00});
  writeReg(0x95, {0x96, 0x16, 0x00, 0x00, 0xFF});
  writeReg(0x96, {0x44, 0x53, 0x03, 0x12, 0x23, 0x24, 0x06, 0x05, 0x94, 0x27, 0x00, 0x44});
  writeReg(0x97, {0x44, 0x53, 0x47, 0x56, 0x20, 0x20, 0x02, 0x01, 0x94, 0x27, 0x00, 0x44});
  writeReg(0xBA, {0x55, 0x94, 0x2D, 0x94, 0x27});
  writeReg(0x9A, {0x40, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00});
  writeReg(0x9B, {0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00});
  writeReg(0x9C, {0x5C, 0x12, 0x00, 0x00, 0x10, 0x12, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x00});
  writeReg(0x9D, {0x8A, 0x51, 0x00, 0x00, 0x00, 0x80, 0x1E, 0x01});
  writeReg(0x9E, {0x51, 0x00, 0x00, 0x00, 0x80, 0x1E, 0x01});
  writeReg(0xB4, {0x1D, 0x1C, 0x1E, 0x0B, 0x14, 0x02, 0x13, 0x09, 0x1E, 0x00, 0x1E, 0x10});
  writeReg(0xB5, {0x1D, 0x1C, 0x1E, 0x0A, 0x15, 0x03, 0x11, 0x08, 0x1E, 0x01, 0x1E, 0x12});
  writeReg(0xB6, {0x77, 0x77, 0x00, 0x0A, 0xFF, 0x0A, 0xFF});
  writeReg(0x86, {0xCD, 0x04, 0xB1, 0x02, 0x58, 0x12, 0x58, 0x0C, 0x13, 0x01, 0xA5, 0x00, 0xA5, 0xA5});
  writeReg(0xB7, {0x07, 0x0A, 0x0E, 0x06, 0x05, 0x03, 0x2B, 0x03, 0x03, 0x42, 0x07, 0x10, 0x10, 0x2E, 0x3F, 0x0D});
  writeReg(0xB8, {0x07, 0x0A, 0x0D, 0x05, 0x05, 0x02, 0x2B, 0x02, 0x03, 0x42, 0x06, 0x10, 0x0F, 0x2E, 0x3F, 0x0D});
  writeReg(0xB9, {0x23, 0x23});
  writeReg(0xBF, {0x10, 0x14, 0x14, 0x0B, 0x0B, 0x0B});
  writeReg(0xF2, {0x00});
  writeReg(0x73, {0x04, 0xDA, 0x12, 0x54, 0x47});
  writeReg(0x77, {0x6B, 0x5B, 0xFD, 0xC3, 0xC5});
  writeReg(0x7A, {0x15, 0x27});
  writeReg(0x7B, {0x04, 0x57});
  writeReg(0x7E, {0x01, 0x0E});
  writeReg(0xBF, {0x36});
  writeReg(0xE3, {0x40, 0x40});
  writeReg(0xF0, {0x00});
  writeReg(0xD0, {0x00});
  writeReg(0x2A, {0x00, 0x00, 0x01, 0x3F});   // CASET 0..319
  writeReg(0x2B, {0x00, 0x00, 0x01, 0xDF});   // RASET 0..479
  writeReg(0x21, nullptr, 0);                 // INVON
  writeReg(0x11, nullptr, 0);                 // SLPOUT
  delay(120);
  writeReg(0x29, nullptr, 0);                 // DISPON
  writeReg(0x2C, nullptr, 0);                 // RAMWR
  writeReg(0x3A, {0x01});                     // COLMOD (vendor value)
  writeReg(0x36, {0x00});                     // MADCTL: native orientation
  writeReg(0x35, {0x01});                     // TE on
  delay(20);
}

bool begin() {
  pinMode(PIN_LCD_BL, OUTPUT);
  digitalWrite(PIN_LCD_BL, LOW);

  spi_bus_config_t bus = {};
  bus.data0_io_num = PIN_LCD_D0;
  bus.data1_io_num = PIN_LCD_D1;
  bus.sclk_io_num = PIN_LCD_SCK;
  bus.data2_io_num = PIN_LCD_D2;
  bus.data3_io_num = PIN_LCD_D3;
  bus.max_transfer_sz = BAND_BYTES + 16;
  // NOTE: do not add SPICOMMON_BUSFLAG_QUAD here. On GPIO9-14 (IOMUX pins)
  // the driver then mis-detects octal mode and the screen stays black.
  bus.flags = SPICOMMON_BUSFLAG_MASTER;
  if (spi_bus_initialize(SPI2_HOST, &bus, SPI_DMA_CH_AUTO) != ESP_OK) return false;

  spi_device_interface_config_t dev = {};
  dev.command_bits = 8;
  dev.address_bits = 24;
  dev.mode = 0;
  dev.clock_speed_hz = LCD_SPI_HZ;
  dev.spics_io_num = PIN_LCD_CS;
  dev.queue_size = 2;
  dev.flags = SPI_DEVICE_HALFDUPLEX;
  if (spi_bus_add_device(SPI2_HOST, &dev, &s_dev) != ESP_OK) return false;

  s_band = (uint8_t*)heap_caps_malloc(BAND_BYTES, MALLOC_CAP_DMA | MALLOC_CAP_INTERNAL);
  if (!s_band) return false;

  // The panel has no reset pin (tied to the chip enable), so just init it.
  initPanel();

  // Clear to black before turning the backlight on.
  memset(s_band, 0, BAND_BYTES);
  for (int y = 0; y < LCD_NATIVE_H; y += BAND_ROWS) {
    uint8_t ra[4] = {(uint8_t)(y >> 8), (uint8_t)y, (uint8_t)((y + BAND_ROWS - 1) >> 8), (uint8_t)(y + BAND_ROWS - 1)};
    writeReg(0x2A, {0x00, 0x00, 0x01, 0x3F});
    writeReg(0x2B, ra, 4);
    writePixels(0x2C, s_band, BAND_BYTES);
  }
  setBacklight(true);
  return true;
}

void setBacklight(bool on) { digitalWrite(PIN_LCD_BL, on ? HIGH : LOW); }

void pushFrame(const uint16_t* pixels) {
  const uint8_t* src = (const uint8_t*)pixels;
  for (int y = 0; y < LCD_NATIVE_H; y += BAND_ROWS) {
    int rows = min(BAND_ROWS, LCD_NATIVE_H - y);
    size_t bytes = (size_t)rows * LCD_NATIVE_W * 2;
    memcpy(s_band, src + (size_t)y * LCD_NATIVE_W * 2, bytes);
#if LCD_SWAP_BYTES
    for (size_t i = 0; i < bytes; i += 2) { uint8_t t = s_band[i]; s_band[i] = s_band[i + 1]; s_band[i + 1] = t; }
#endif
    int y2 = y + rows - 1;
    uint8_t ra[4] = {(uint8_t)(y >> 8), (uint8_t)y, (uint8_t)(y2 >> 8), (uint8_t)y2};
    writeReg(0x2A, {0x00, 0x00, 0x01, 0x3F});
    writeReg(0x2B, ra, 4);
    writePixels(0x2C, s_band, bytes);
  }
}

}  // namespace St77922
